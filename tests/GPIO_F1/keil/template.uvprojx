# Keil uVision project template.uvprojx, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1 +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\stm32\variants\stm32f1\inc;..\..\..\stm32\cmsis\variants\stm32f1;..\keil
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../src/: main.c stm32f10x_it.c
    ../../../stm32/variants/stm32f1/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c
  group CM3
    ./: startup_stm32f10x_md.s core_cm3.c
    ../../../stm32/cmsis/variants/stm32f1/: system_stm32f10x.c
